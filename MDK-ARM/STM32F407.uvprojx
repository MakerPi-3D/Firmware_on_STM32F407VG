# Keil uVision project STM32F407.uvprojx, settings and files
target STM32F407 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32F407 +hex
  AfterMake: fromelf.exe --bin -o "..\APP2.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,STM32F40_41xxx,__USE_C99_MATH,ARM_MATH_CM4,USE_USB_OTG_HS,USE_EMBEDDED_PHY,CHECK_EXTRUDER_THERMISTOR_FALLS_OFF,CAL_Z_ZERO_OFFSET
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FatFs/src;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\UserAddons\config;..\UserAddons\feature;..\UserAddons\gcode;..\UserAddons\grbl;..\UserAddons\gui;..\UserAddons\lcd;..\UserAddons\machine;..\UserAddons\task;..\UserAddons\user;..\UserAddons\usb_device\STM32F4xx_StdPeriph_Driver\inc;..\UserAddons\usb_device\STM32_USB_Device_Library\Core\inc;..\UserAddons\usb_device\STM32_USB_Device_Library\Class\cdc\inc;..\UserAddons\usb_device\STM32_USB_OTG_Driver\inc;..\UserAddons\usb_device\Source;..\UserAddons\usb_device\Source\USB
  asm include: ..\Inc
  memory RVCT4: ROM 0x8020000 size 0xe0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c bsp_driver_sd.c sd_diskio.c fatfs.c fatfs_platform.c usbh_diskio.c freertos.c usb_host.c usbh_conf.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_hcd.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_sram.c stm32f4xx_hal_iwdg.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c cc936.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/USB_Host_Library
    ../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
    ../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group UserAddons/config
    ../UserAddons/config/: config_model_tables.cpp file_sgcode.cpp file_touch_data_bin.cpp sg_util.cpp sysconfig.cpp sysconfig_data.cpp
  group UserAddons/feature
    ../UserAddons/feature/: Alter.cpp autobedleveling.cpp boardtest.cpp controlfunction.cpp controlxyz.cpp filamentcontrol.cpp functioncustom.cpp infrared_auto_bed_level.cpp infrared_bed_level_adjust.cpp infrared_z_zero_adjust.cpp lightcontrol.cpp materialcheck.cpp mechanical_bed_level_adjust.cpp midwaychangematerial.cpp poweroffrecovery.cpp simplefunction.cpp
  group UserAddons/gcode
    ../UserAddons/gcode/: g1.cpp g2_g3.cpp g28.cpp g29.cpp g92.cpp gcode_global_params.cpp gcodebufferhandle.cpp m84.cpp m92.cpp m104_m109_m140_m190_m2004.cpp m105_m114.cpp m106_m107.cpp m200_m201_m203_m204_m205.cpp m220_m221.cpp m301_m302_m303.cpp m305_m2501_m2502_m2503.cpp m600_m601_m602.cpp gcode.cpp
  group UserAddons/grbl
    ../UserAddons/grbl/: ConfigurationStore.cpp grbl_acc_dec.cpp planner.cpp stepper.cpp temperature.cpp temperature_pid_output_factor.cpp temperature_pid_temp.cpp vector_3.cpp
  group UserAddons/gui
    ../UserAddons/gui/: guicontrol.cpp PrintControl.cpp RespondGUI.cpp UdiskControl.cpp USBFileTransfer.cpp view_change_filament.cpp view_common.cpp view_door_open_warning.cpp view_filament_control.cpp view_file_scan.cpp view_icons.cpp view_main_display.cpp view_mat_check.cpp view_measure_z_max_limit.cpp view_move_xyz.cpp view_no_udisk.cpp view_pause_print.cpp view_pic_display.cpp view_power_off_recover.cpp view_prepare.cpp view_print_confirm.cpp view_print_finish.cpp view_print_set.cpp view_set_function.cpp view_set_machine.cpp view_setting.cpp view_status.cpp view_stop_print.cpp view_warning_info.cpp
  group UserAddons/lcd
    ../UserAddons/lcd/: font.c lcd.c lcd_common.c lcd_ili9488.c lcd_nt35310.c LCD_SSD1963.c
  group UserAddons/machine
    ../UserAddons/machine/: mach_K5.cpp mach_M14.cpp mach_M14R03.cpp mach_M14S.cpp mach_M41G.cpp mach_M2030.cpp mach_M2030HY.cpp mach_M2048.cpp mach_M3145.cpp mach_M3145K.cpp mach_M3145S.cpp mach_M4141.cpp mach_M4141S_M4141SNEW_AMP410W.cpp machine.cpp machine_custom.cpp machinecustom.cpp
  group UserAddons/task
    ../UserAddons/task/: gui_task.cpp print_task.cpp read_udisk_task.cpp ref_data_task.cpp respond_gui_task.cpp start_default_task.cpp
  group UserAddons/user
    ../UserAddons/user/: uart_process.cpp touch.cpp watch_dog.c user_usbd.c user_interface.c user_fatfs.c uart.c interface.c globalvariables_ccmram.c globalvariables.c delay.c
  group UsbDevice
    ../UserAddons/usb_device/Source/USB/: usb_bsp.c usbd_desc.c usbd_usr.c
    ../UserAddons/usb_device/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../UserAddons/usb_device/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
    ../UserAddons/usb_device/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
    ../UserAddons/usb_device/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c
software components: CMSIS:CORE 4.3.0
